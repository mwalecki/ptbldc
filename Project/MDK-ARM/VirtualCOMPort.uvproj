# Keil uVision project VirtualCOMPort.uvproj, settings and files
target MW1110A (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210B-EVAL +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, HSE_VALUE=16000000, MW1110A
  c include: ..\inc;..\..\Library\CMSIS_2-10\Device\ST\STM32F10x\Include;..\..\Library\STM32_USB-FS-Device_Driver_3-4-0\inc;..\..\Library\STM32F10x_StdPeriph_Driver_3-6-1\inc;..\..\..\..\_COMM_nfv2;..\..\..\..\_COMM_mycrc;..\..\..\..\_COMM_myscpi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../src/: adc.c clock.c eebackup.c eeprom.c hw_config.c interrupts.c io.c led.c main.c motor.c servo.c systick.c usart1.c usart3.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c myscpi.c stm32_it.c ax12.c usb.c nfv2_config.c pid.c kurierhead.c usart2.c
  group Extern
    ../../../../_COMM_myscpi/: myscpi.h myscpi_defines.h
    ../../../../_COMM_nfv2/: nfv2.c nfv2.h
    ../../../../_COMM_mycrc/: mycrc.c mycrc.h
  group CMSIS
    ../src/: system_stm32f10x.c
    ../../Library/CMSIS_2-10/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_md.s
  group USB-FS-Device_Driver
    ../../Library/STM32_USB-FS-Device_Driver_3-4-0/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32F10x_StdPeriph_Driver
    ../../Library/STM32F10x_StdPeriph_Driver_3-6-1/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c misc.c
target MW1110C (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: as above
  output: STM3210B-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, HSE_VALUE=16000000, MW1110C
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target MW1110A KurierHead (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: as above
  output: STM3210B-EVAL +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, HSE_VALUE=16000000, MW1110A, KURIERHEAD
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
